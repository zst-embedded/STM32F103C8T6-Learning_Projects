# Keil uVision project MusicalTone.uvprojx, settings and files
target MusicalTone (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MusicalTone
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103x6
  c misc: --C99
  c include: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f1xx_hal_msp.c main.c stm32f1xx_it.c PWMTone.c PWMTone.h PA0_Handler.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_dma.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_rcc_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Application/MDK-ARM
    ./: startup_stm32f103x6.s
software components: CMSIS:CORE 4.1.0
